# Keil uVision project CA51F3_Touch_DemoProj.uvproj, settings and files
target CA51F (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: ca51f3 +hex
  c flags: Optimize=9
  link misc: REMOVEUNUSED
  group Sources
    ./: main.c interrupt.c
    ./Library/Sources/: delay.c system_clock.c uart.c
  group TS_lib
    ./TS_Lib/Sources/: debug.c ts_api.c ts_service.LIB
  group Lib
    ./Library/Lib/: STARTUP.A51
