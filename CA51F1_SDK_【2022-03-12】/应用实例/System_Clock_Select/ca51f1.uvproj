# Keil uVision project ca51f1.uvproj, settings and files
target CA51F1 (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: ca51f1 +hex
  c flags: Optimize=9 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Files
    ./source/: main.c delay.c system_clock.c
  group Lib
    ./lib/: STARTUP.A51
